<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LDR\LDR.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\LDR-multiple\LDR-multiple.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Servo\Servo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\ServoLDRControl\ServoLDRControl.ewp</path>
    </project>
    <batchBuild />
</workspace>
